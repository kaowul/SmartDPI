## xtstring/src/Kconfig
```kconfig
config xtstring
　　tristate "show my xtstring"
　　default n
　　help
　　　This is a example, for debugging kernel model.
　　　If unsure, say N.
```
